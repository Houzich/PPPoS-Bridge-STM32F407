# Keil uVision project BRIDGE.uvprojx, settings and files
target BRIDGE (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: BRIDGE +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Inc;  ../Middlewares/Third_Party/LwIP/src/include;  ../Middlewares/Third_Party/LwIP/system;  ../Drivers/STM32F4xx_HAL_Driver/Inc;  ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;  ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;  ../Middlewares/Third_Party/LwIP/src/include/netif/ppp;  ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;  ../Middlewares/Third_Party/FreeRTOS/Source/include;  ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;  ../Middlewares/Third_Party/LwIP/src/include/lwip;  ../Middlewares/Third_Party/LwIP/src/include/lwip/apps;  ../Middlewares/Third_Party/LwIP/src/include/lwip/priv;  ../Middlewares/Third_Party/LwIP/src/include/lwip/prot;  ../Middlewares/Third_Party/LwIP/src/include/netif;  ../Middlewares/Third_Party/LwIP/src/include/posix;  ../Middlewares/Third_Party/LwIP/src/include/posix/sys;  ../Middlewares/Third_Party/LwIP/system/arch;  ../Drivers/CMSIS/Include;  ..\Bridge\Data;  ..\Bridge\LAN;  ..\Bridge\PPPoS;  ..\Bridge\GSM;  ..\Bridge\Forward
  asm include: ..\Inc;..\\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Define
    ../Inc/: FreeRTOSConfig.h lwipopts.h
    ../Bridge/Data/: Bridge_Define.h
    ../Middlewares/Third_Party/LwIP/src/include/lwip/: opt.h
  group Application/User
    ../Src/: stm32f4xx_hal_timebase_TIM.c lwip.c stm32f4xx_it.c freertos.c stm32f4xx_hal_msp.c ethernetif.c main.c
  group Bridge/Data
    ../Bridge/Data/: Bridge_Data.c Bridge_Data.h Bridge_Define.h Note_Bridge_Data.txt Note_Bridge_Define.txt
  group Bridge/LAN
    ../Bridge/LAN/: HTTP_Server.c HTTP_Server.h Note_HTTP_Server.txt
  group Bridge/GSM
    ../Bridge/GSM/: GSM.c GSM.h SIM800_USART.c SIM800_USART.h Note_GSM.txt Note_SIM800_USART.txt
  group Bridge/PPPoS
    ../Bridge/PPPoS/: Application_PPPoS.c Application_PPPoS.h PPPoS_HTTP_Client.c PPPoS_HTTP_Client.h PPPoS_Interface.c PPPoS_Interface.h Note_Application_PPPoS.txt Note_HTTP_Client.txt Note_PPPoS_Interface.txt
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: timers.c event_groups.c croutine.c queue.c list.c tasks.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_dma.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal.c stm32f4xx_hal_flash.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_eth.c stm32f4xx_hal_rcc.c stm32f4xx_hal_uart.c stm32f4xx_hal_gpio.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_cortex.c
  group Middlewares/LwIP
    ../Middlewares/Third_Party/LwIP/src/core/: dns.c pbuf.c inet_chksum.c netif.c ip.c raw.c mem.c memp.c init.c def.c sys.c tcp_out.c udp.c stats.c tcp.c timeouts.c tcp_in.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv4/: igmp.c etharp.c dhcp.c ip4.c autoip.c ip4_addr.c ip4_frag.c icmp.c
    ../Middlewares/Third_Party/LwIP/src/netif/ppp/: upap.c eap.c pppos.c pppol2tp.c eui64.c chap-md5.c multilink.c ecp.c ccp.c pppapi.c ipv6cp.c pppcrypt.c demand.c lcp.c ppp.c vj.c chap-new.c pppoe.c magic.c mppe.c fsm.c utils.c chap_ms.c ipcp.c auth.c
    ../Middlewares/Third_Party/LwIP/src/api/: sockets.c netdb.c tcpip.c api_lib.c err.c netbuf.c api_msg.c netifapi.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv6/: icmp6.c inet6.c ethip6.c mld6.c ip6_addr.c dhcp6.c ip6.c nd6.c ip6_frag.c
    ../Middlewares/Third_Party/LwIP/src/apps/mqtt/: mqtt.c
    ../Middlewares/Third_Party/LwIP/src/netif/: lowpan6.c slipif.c ethernet.c
    ../Middlewares/Third_Party/LwIP/system/OS/: sys_arch.c
  group Libraries
    ../Libraries/HAL/: HAL.lib
  group TEMP
    ../Bridge/Forward/: Forward.c Forward.h Note_Forward.txt
  group Drivers/CMSIS
    ..//Src/: system_stm32f4xx.c
target HAL (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: as above
  output: HAL +hex (library)
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: as above
  asm include: ..\Inc;..\\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
target LwIP (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: as above
  output: LwIP +hex (library)
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: as above
  asm include: ..\Inc;..\\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
software components: CMSIS:CORE 5.1.1, Compiler:I/O:STDOUT 1.4.0
